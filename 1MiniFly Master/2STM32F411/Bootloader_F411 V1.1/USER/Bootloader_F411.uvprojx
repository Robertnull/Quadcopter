# Keil uVision project Bootloader_F411.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 for Certification (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader_F411 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\SYSTEM\interface;..\HARDWARE\interface;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP\interface;..\PROTOCOL;..\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group SYSTEM
    ../SYSTEM/src/: sys.c delay.c
  group HARDWARE
    ../HARDWARE/src/: led.c stmflash.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../USB/USB_APP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group PROTOCOL
    ../PROTOCOL/: check.c protocol.c
  group IAP
    ../IAP/: iap.c
  group README
    ../: readme.txt
