# Keil uVision project nrf_firmware.uvprojx, settings and files
target nrf_firmware (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf_firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51,BLE_STACK_SUPPORT_REQD,BLE=0,S110=1
  c include: ..\nrf51_sdk\nrf51822\Include\gcc;..\nrf51_sdk\nrf51822\Include;..\HARDWARE\interface;..\COMMUNICATE\interface
  memory RVCT4: ROM 0x0 size 0x2a000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c system_nrf51.c arm_startup_nrf51.s
  group COMMUNICATE
    ../COMMUNICATE/src/: radiolink.c uartlink.c
  group HARDWARE
    ../HARDWARE/src/: button.c config_param.c esb.c pm.c systick.c uart.c
  group README
    ../: README.txt
